# Keil uVision project TL_2828.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::.\ARMCompiler6.14.1)
  device: R7FA2E1A7 Renesas
  pack: Renesas.RA_DFP.3.6.0
  cpu: CPUTYPE("Cortex-M23") noFPU2 CLOCK(12000000) ELITTLE
  output: TL_2828 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: QE_TOUCH_CONFIGURATION
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\ra\fsp\inc\api;.\ra\fsp\inc\instances;.\ra\fsp\src\bsp\mcu\all;.\qe_gen;.\src;.\pmlibrary_210623_v001_lib;.\photosensitive;.\pmlibrary
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Source Group 1
    ./qe_gen/: qe_touch_config.c qe_touch_config.h qe_touch_define.h qe_touch_sample.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_entry.h
  group PM25Lib
    ./pmlibrary/: pmLib.h 使用说明.txt pmlibrary_NALA.lib
  group PhotosensitiveLib
    ./photosensitive/: Photosensitive.h photosensitive_lib_NALA.lib
software components: Flex Software:RA Configuration 1.0.0
